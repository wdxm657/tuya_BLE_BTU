# IAR project Project.ewp, settings and files
configuration Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32F040xB Puya PY32F040xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32F040xB; VECT_TAB_BASE=0x08000000
  ICCARM.CCIncludePath2: ..\..\resource\PY32F040_IAP_APP_Firmware\Drivers\BSP\PY32F040xx_Start_Kit; ..\..\resource\PY32F040_IAP_APP_Firmware\Drivers\CMSIS\Device\PY32F040\Include; ..\..\resource\PY32F040_IAP_APP_Firmware\Drivers\CMSIS\Include; ..\..\resource\PY32F040_IAP_APP_Firmware\Drivers\PY32F040_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32f040xB_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../resource/PY32F040_IAP_APP_Firmware/Drivers/BSP/PY32F040xx_Start_Kit/: py32f040xx_Start_Kit.c
  group Drivers/CMSIS
    ../Src/: system_py32f040.c
  group Drivers/PY32F040_HAL_Driver
    ../../resource/PY32F040_IAP_APP_Firmware/Drivers/PY32F040_HAL_Driver/Src/: py32f040_hal.c py32f040_hal_cortex.c py32f040_hal_dma.c py32f040_hal_gpio.c py32f040_hal_i2c.c py32f040_hal_pwr.c py32f040_hal_rcc.c py32f040_hal_rcc_ex.c py32f040_hal_uart.c
  group Example/EWARM
    ./: startup_py32f040xx.s
  group Example/User
    ../Src/: app_bootloader.c app_flash.c app_i2c.c app_usart.c app_wdg.c main.c py32f040_hal_msp.c py32f040_it.c
