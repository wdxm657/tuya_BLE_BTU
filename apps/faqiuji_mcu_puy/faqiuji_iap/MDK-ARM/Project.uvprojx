# Keil uVision project Project.uvprojx, settings and files
target PY32F040xB_Project (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: PY32F040xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.20
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: VECT_TAB_BASE=0x08000000,USE_HAL_DRIVER,PY32F040xB
  c include: ..\Inc;..\..\resource\PY32F040_IAP_APP_Firmware\Drivers\BSP\PY32F040xx_Start_Kit;..\..\resource\PY32F040_IAP_APP_Firmware\Drivers\CMSIS\Include;..\..\resource\PY32F040_IAP_APP_Firmware\Drivers\CMSIS\Device\PY32F040\Include;..\..\resource\PY32F040_IAP_APP_Firmware\Drivers\PY32F040_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Common
    ../Src/: system_py32f040.c
    ./: startup_py32f040xx.s
  group Application/User
    ../Src/: main.c app_bootloader.c app_flash.c app_i2c.c app_usart.c app_wdg.c py32f040_hal_msp.c py32f040_it.c
  group Drivers/BSP/PY32F040xx_Start_Kit
    ../../resource/PY32F040_IAP_APP_Firmware/Drivers/BSP/PY32F040xx_Start_Kit/: py32f040xx_Start_Kit.c
  group Drivers/PY32F040_HAL_Driver
    ../../resource/PY32F040_IAP_APP_Firmware/Drivers/PY32F040_HAL_Driver/Src/: py32f040_hal.c py32f040_hal_cortex.c py32f040_hal_dma.c py32f040_hal_gpio.c py32f040_hal_rcc.c py32f040_hal_rcc_ex.c py32f040_hal_pwr.c py32f040_hal_i2c.c py32f040_hal_uart.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
