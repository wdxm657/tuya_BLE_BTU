# Keil uVision project Project.uvprojx, settings and files
target FAQIUJI_APP_A (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: PY32F071xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.20
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(8000000) ELITTLE
  output: FAQIUJI_APP_A +hex
  AfterMake: $K\ARM\ARM_Compiler_5.06u7\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F071xB
  c include: ..\Inc;..\..\resource\PY32F071_Firmware_V1.1.3\Projects\PY32F071-STK\Example\DAC\DAC_SingleGeneration\Inc;..\..\resource\PY32F071_Firmware_V1.1.3\Drivers\CMSIS\Include;..\..\resource\PY32F071_Firmware_V1.1.3\Drivers\CMSIS\Device\PY32F071\Include;..\..\resource\PY32F071_Firmware_V1.1.3\Drivers\PY32F071_HAL_Driver\Inc;..\..\resource\PY32F071_Firmware_V1.1.3\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\resource\PY32F071_Firmware_V1.1.3\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Common
    ../../resource/PY32F071_Firmware_V1.1.3/Templates/PY32F071xx_Templates/MDK-ARM/: startup_py32f071xx.s
    ../../resource/PY32F071_Firmware_V1.1.3/Templates/PY32F071xx_Templates/Src/: system_py32f071.c
  group Application/User
    ../Src/: main.c faqiuji_audio.c faqiuji_record.c py32f040_hal_msp.c py32f040_it.c py32f040_hal_timebase_tim.c
  group Middlewares/FreeRTOS
    ../../resource/PY32F071_Firmware_V1.1.3/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_portable
    ../../resource/PY32F071_Firmware_V1.1.3/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../resource/PY32F071_Firmware_V1.1.3/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group PY32F071_HAL_Driver
    ../../resource/PY32F071_Firmware_V1.1.3/Drivers/PY32F071_HAL_Driver/Src/: py32f071_hal.c py32f071_hal_rcc.c py32f071_hal_rcc_ex.c py32f071_hal_gpio.c py32f071_hal_dma.c py32f071_hal_pwr.c py32f071_hal_uart.c py32f071_hal_tim.c py32f071_hal_tim_ex.c py32f071_hal_cortex.c py32f071_hal_adc.c py32f071_hal_adc_ex.c py32f071_hal_flash.c py32f071_hal_dac.c py32f071_hal_dac_ex.c
  group Doc
    ../../: FLASH_LAYOUT.md
software components: CMSIS:CORE 5.2.0
