# Keil uVision project Project_APP_B.uvprojx, settings and files
target FAQIUJI_APP_B (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: PY32F040xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.20
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08010000,0x0000C000) CPUTYPE("Cortex-M0+") CLOCK(8000000) ELITTLE
  output: FAQIUJI_APP_B +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F040xB,FAQIUJI_APP_SLOT_B
  c include: ..\Inc;..\..\resource\PY32F040_Firmware_V1.1.3\Drivers\BSP\py32f040xx_Start_Kit;..\..\resource\PY32F040_Firmware_V1.1.3\Drivers\CMSIS\Include;..\..\resource\PY32F040_Firmware_V1.1.3\Drivers\CMSIS\Device\PY32F040\Include;..\..\resource\PY32F040_Firmware_V1.1.3\Drivers\PY32F040_HAL_Driver\Inc;..\..\resource\PY32F040_Firmware_V1.1.3\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\resource\PY32F040_Firmware_V1.1.3\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x08010000 size 0x0000C000
  memory RVCT5: ROM 0x1fff3100 size 0x20
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Common
    ./: startup_py32f040xx.s
    ../Src/: system_py32f040.c
  group Application/User
    ../Src/: main.c faqiuji_protocol.c faqiuji_launcher.c faqiuji_device.c py32f040_hal_msp.c py32f040_it.c py32f040_hal_timebase_tim.c faqiuji_ota.c
    ../../common/: faqiuji_image.c
  group Middlewares/FreeRTOS
    ../../resource/PY32F040_Firmware_V1.1.3/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_portable
    ../../resource/PY32F040_Firmware_V1.1.3/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../resource/PY32F040_Firmware_V1.1.3/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group BSP/py32f040xx_Start_Kit
    ../../resource/PY32F040_Firmware_V1.1.3/Drivers/BSP/py32f040xx_Start_Kit/: py32f040xx_Start_Kit.c
  group PY32F040_HAL_Driver
    ../../resource/PY32F040_Firmware_V1.1.3/Drivers/PY32F040_HAL_Driver/Src/: py32f040_hal.c py32f040_hal_flash.c
    ../../resource/PY32F040_Firmware_V1.1.3/Drivers/PY32F040_HAL_Driver/src/: py32f040_hal_rcc.c py32f040_hal_rcc_ex.c py32f040_hal_gpio.c py32f040_hal_dma.c py32f040_hal_pwr.c py32f040_hal_uart.c py32f040_hal_tim.c py32f040_hal_tim_ex.c py32f040_hal_cortex.c py32f040_hal_adc.c py32f040_hal_adc_ex.c
  group Doc
    ../../: FLASH_LAYOUT.md
software components: CMSIS:CORE 5.2.0
